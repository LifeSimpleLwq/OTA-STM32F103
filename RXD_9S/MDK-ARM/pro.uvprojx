# Keil uVision project pro.uvprojx, settings and files
target pro (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: pro +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c misc: --C99
  c include: ../Inc;        ../Drivers/STM32F1xx_HAL_Driver/Inc;        ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;        ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;        ../Drivers/CMSIS/Include;        ..\BSP;        ..\BSP\BSP_Drivers;        ..\BSP\BSP_OTA
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x3c00
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_spi.c stm32f1xx_hal_uart.c stm32f1xx_hal_cortex.c stm32f1xx_hal.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_rcc.c
  group Application/User
    ../Src/: main.c spi.c stm32f1xx_it.c gpio.c stm32f1xx_hal_msp.c usart.c tim.c
  group BSP
    ../BSP/: BSP_Main.c BSP_SYS.c
  group BSP_Driver
    ../BSP/BSP_Drivers/: BSP_Flash.c
  group BSP_OTA
    ../BSP/BSP_OTA/: BSP_24L01.c BSP_OTA.C
  group README
    ../ReadMe/: README.txt
software components: CMSIS:CORE 4.1.0
