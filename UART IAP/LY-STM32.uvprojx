# Keil uVision project LY-STM32.uvprojx, settings and files
target LY-STM32 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F105RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BootLoader +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_CL
  c include: .\Lib\inc;.\System;.\user;.\User\BSP_Drivers
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x3c00
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user
    ./user/: main.c stm32f10x_it.c
    ./User/: usart.c android.c led.c watchdog.c
  group BSP_Drivers
    ./User/BSP_Drivers/: BSP_Flash.c BSP_OTA.c
  group asm
    ./asm/: startup_stm32f10x_cl.s
  group Lib
    ./Lib/SRC/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_usart.c
  group System
    ./System/: core_cm3.c system_stm32f10x.c
  group Readme
    ./Readme/: README.TXT
software components: CMSIS:CORE 5.1.2
