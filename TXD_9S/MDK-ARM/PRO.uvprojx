# Keil uVision project PRO.uvprojx, settings and files
target PRO (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: PRO +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c misc: --C99
  c include: ../Inc;          ../Drivers/STM32F1xx_HAL_Driver/Inc;          ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;          ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;          ../Drivers/CMSIS/Include;          ..\BSP;          ..\BSP\BSP_Drivers;          ..\BSP\BSP_OTA
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_uart.c stm32f1xx_hal_cortex.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_rcc.c
  group Application/User
    ../Src/: main.c spi.c gpio.c stm32f1xx_it.c stm32f1xx_hal_msp.c usart.c
  group BSP
    ../BSP/: BSP_Main.c BSP_SYS.c
  group BSP_Drivers
    ../BSP/BSP_Drivers/: BSP_flash.c BSP_Malloc.c
  group BSP_OTA
    ../BSP/BSP_OTA/: BSP_24L01.C BSP_OTA.c
  group README
    ../ReadMe/: ReadMe.TXT
software components: CMSIS:CORE 4.1.0
